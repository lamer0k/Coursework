# IAR project BookCpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ; utils; Ahl; App; Ahl\Button; Ahl\Led; App\LedsController; CMSIS; FreeRtos; FreeRtos\Include; FreeRtos\Wrapper; FreeRtos\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: 
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: BookCpp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    ./: FreeRTOSConfig.h main.cpp startup_stm32F4xx_md.cpp
  group App/LedsController
    App/LedsController/: ledscontroller.cpp
  group FreeRtos
    FreeRtos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRtos/Portable
    FreeRtos/portable/MemMang/: heap_1.c
    FreeRtos/portable/IAR/ARM_CM4F/: port.c portasm.s
  group FreeRtos/Wrapper
    FreeRtos/wrapper/: frtosWrapper.cpp frtoswrapper.h iactiveobject.h
